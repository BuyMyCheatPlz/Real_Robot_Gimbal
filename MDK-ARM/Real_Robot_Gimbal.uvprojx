# Keil uVision project Real_Robot_Gimbal.uvprojx, settings and files
target Real_Robot_Gimbal (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Real_Robot_Gimbal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Tasks/Inc;../Hardware_Drivers/Inc;../Hardware_Drivers/Can/Inc;../Hardware_Drivers/m3508+c620/Inc;../Hardware_Drivers/m2006+c610/Inc;../Hardware_Drivers/Gm6020/Inc;../Hardware_Drivers/Dm4310/Inc;../Hardware_Drivers/Remote_Ctrl/Inc;../Hardware_Drivers/Bmi088/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Hardware_Drivers
    ../Hardware_Drivers/Src/: hardware_drivers.c
    ../Hardware_Drivers/Can/Src/: motor_common.c can_motor_bus.c
    ../Hardware_Drivers/m3508+c620/Src/: m3508.c
    ../Hardware_Drivers/m2006+c610/Src/: m2006.c
    ../Hardware_Drivers/Gm6020/Src/: gm6020.c
    ../Hardware_Drivers/Dm4310/Src/: dm4310.c
    ../Hardware_Drivers/Remote_Ctrl/Src/: dbus.c
    ../Hardware_Drivers/Bmi088/Src/: bmi088.c
  group Application/User/Tasks
    ../Tasks/Inc/: config.h pid_parameter.h notch_filter.h yaw_hold.h yaw_startup.h
    ../Tasks/Src/: data_process.c pid_parameter.c pid_calc.c notch_filter.c yaw_hold.c yaw_startup.c vofa.c launch.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
